options:
  parameters:
    generate_options: qt_gui
    id: tx_from_file
    output_language: python
    title: TX from Sigmf
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e7
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767.0'
    vector_input: 'False'
  states: {}
- name: blocks_sigmf_source_minimal_0_0
  id: blocks_sigmf_source_minimal
  parameters:
    repeat: 'False'
    type: complex short (sc16_le)
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'Depending what datatype was used to save the SigMF file use this conversion or not. The one from IShort to Coomplex type. '
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 1622e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_hackrf_sink_0_0
  id: soapy_hackrf_sink
  parameters:
    bandwidth: 1e7
    center_freq: 1622e6
    samp_rate: samp_rate
    type: fc32
    vga: '33'
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', soapy_hackrf_sink_0_0, '0']
- [blocks_sigmf_source_minimal_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
